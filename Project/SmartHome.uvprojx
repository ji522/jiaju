# Keil uVision project SmartHome.uvprojx, settings and files
target SmartHome_SingleTask (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\1_App;..\2_Device;..\3_Protocol;..\4_MiddleWare;..\5_Platform;..\6_ModuleDrives;..\7_HAL\CMSIS\Include;..\7_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\7_HAL\STM32F1xx_HAL_Driver\Inc;..\7_HAL\STM32F1xx_HAL_Driver\Inc\Legacy;..\8_Core;..\4_MiddleWare\FreeRTOS-Kernel\include;..\4_MiddleWare\FreeRTOS-Kernel\portable\MemMang;..\4_MiddleWare\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;..\3_Protocol\MQTTClient-C\src;..\3_Protocol\MQTTClient-C\src\FreeRTOS;..\3_Protocol\MQTTPacket\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../1_App/: main.c app_key.c app_led.c app_mqtt.c
    ../3_Protocol/MQTTClient-C/samples/FreeRTOS/: MQTTEcho.c
  group Device
    ../2_Device/: dev_io.c dev_net.c
  group Protocol/MQTTClient-C
    ../3_Protocol/MQTTClient-C/src/: MQTTClient.c
    ../3_Protocol/MQTTClient-C/src/FreeRTOS/: MQTTFreeRTOS.c
  group Protocol/MQTTPacket
    ../3_Protocol/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MiddleWare/FreeRTOS
    ../4_MiddleWare/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../4_MiddleWare/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../4_MiddleWare/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group Platform
    ../5_Platform/: platform_io.c platform_net.c
  group ModuleDrives
    ../6_ModuleDrives/: driver_buffer.c driver_led_key.c driver_dbg.c driver_net.c driver_hal_timebase.c
  group HAL
    ../7_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Core
    ../8_Core/: stm32f1xx_hal_conf.h stm32f1xx_it.c system_stm32f1xx.c
    ./: startup_stm32f103xb.s
target SmartHome_MulTask (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
